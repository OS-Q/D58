# Keil uVision project W2.uvproj, settings and files
target CH552 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: headset +hex
  c flags: Optimize=6 SizeSpeed=1
  c include: .\user
  group user
    ./user/: main.c USB.c Timer.c GPIO.c common.c
