# Keil uVision project keyboard.uvproj, settings and files
target keyboard (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user
  group user
    ./user/: main.c Flash.c
